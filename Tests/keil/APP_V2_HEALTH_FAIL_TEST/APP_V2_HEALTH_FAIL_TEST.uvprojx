# Keil uVision project APP_V2_HEALTH_FAIL_TEST.uvprojx, settings and files
target APP_V2_HEALTH_FAIL_TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08004000-0x800ffff) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: APP_V2_HEALTH_FAIL_TEST +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,ROUTER_ROLE=2,APP_PHASE9,APP_HISTORY_ENABLED,IAP_STORAGE_ENABLED,APP_RELEASE_VERSION=2,APP_TEST_TARGET,APP_HEALTH_FAIL_TEST
  c include: ..\..\..\Application\Core\Inc;..\..\..\Application\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\Application\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\..\Application\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\Application\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\Application\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Application\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\Application\Drivers\CMSIS\Include;..\..\..\Application\User\BSP;..\..\..\Application\User\App;..\..\..\Shared;..\..\..\Bootloader\User\BSP;..\..\..\Bootloader\User\Protocol;..\..\..\Application\User\Drivers\SSD1306;../../../Bootloader/User/Drivers/W25Q64
  asm include: ..\..\..\Application\Core\Inc;..\..\..\Application\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\Application\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\..\Application\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\Application\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\Application\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\Application\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\Application\Drivers\CMSIS\Include;..\..\..\Application\User\BSP;..\..\..\Application\User\App;../../../Bootloader/User/Drivers/W25Q64
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\..\Application\MDK-ARM\application.sct
  group Application/MDK-ARM
    ../../../Application/MDK-ARM/: startup_stm32f103xb.s
    ../../../Application/User/App/: app_version.c
  group Application/User/Core
    ../../../Application/Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../Application/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../../../Application/Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../../../Application/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Application/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Application/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Application/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group User/Baseline
    ../../../Application/User/BSP/: app_vector.c
    ../../../Application/User/App/: app_entry.c
  group User/Phase0Modules
    ../../../Application/User/BSP/: backup_domain.c
  group Shared/DMA
    ../../../Shared/: dma_cursor.c
  group App/UART
    ../../../Bootloader/User/BSP/: uart_dma.c
    ../../../Shared/: ring_buffer.c
  group Shared/Protocol
    ../../../Shared/: router.c
  group App/Shell
    ../../../Application/User/App/: app_shell.c
  group Phase9 product owners
    ../../../Application/User/App/: app_runtime.c app_model.c
    ../../../Application/User/BSP/: app_temperature.c app_oled_port.c watchdog_handoff.c
    ../../../Application/User/Drivers/SSD1306/: ssd1306.c
    ../../../Shared/: watchdog_contract.c
  group App_History_SharedDevice
    ../../../Shared/: crc32.c image_contract.c
    ../../../Application/User/App/: app_history.c
    ../../../Application/User/BSP/: app_history_port.c
    ../../../Bootloader/User/Drivers/W25Q64/: w25q64.c w25q64_storage.c
software components: CMSIS:CORE 4.3.0
