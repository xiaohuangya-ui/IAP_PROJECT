# Keil uVision project Bootloader.uvprojx, settings and files
target BOOT_RELEASE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x8003fff) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BOOT_RELEASE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,PHASE8_TEST_ONLY,IAP_STORAGE_ENABLED,IAP_PRODUCT_ENABLED,IAP_PHASE8_ENABLED,PROTOCOL_PRODUCT_BINDING,W25_PRODUCT_BINDING,ROUTER_ROLE=1,BOOT_FIXED_IRQ
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/BSP;../User/Drivers/W25Q64;../User/IAP;../../Shared;../../Bootloader/User/BSP;../../Bootloader/User/Protocol
  asm misc: --pd "BOOT_DIRECT_STARTUP SETA 1"
  asm include: ;../User/BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ./bootloader_product_direct.sct
  link misc: --tailreorder --sort=AlignmentLexical --entry=Reset_Handler --datacompressor=off --no_startup
  group Application/MDK-ARM
    ../User/BSP/: startup_product.s
  group Application/User/Core
    ../Core/Src/: main.c iwdg.c stm32f1xx_hal_msp.c
    ../User/BSP/: gpio_fixed_init.c dma_fixed_init.c spi_fixed_init.c uart_ll_init.c uart_ll_irq.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User/Baseline
    ../../Tests/hardware/: phase8_boot.c
  group User/Phase0Modules
    ../User/BSP/: recovery.c backup_domain.c spi_bus.c
    ../User/Drivers/W25Q64/: w25q64.c
    ../User/IAP/: jump_ll.c
    ../../Shared/: crc32.c image_contract.c
  group User/UART
    ../User/BSP/: uart_ll.c
    ../../Shared/: ring_buffer.c
  group Shared/DMA
    ../../Shared/: dma_cursor.c
  group Shared/Protocol
    ../../Shared/: router.c
  group Protocol/Service
    ../User/Protocol/: boot_protocol.c
  group Protocol/YModem
    ../../Shared/: crc16.c fw_header.c
    ../User/Protocol/: ymodem.c
  group IAP Storage
    ../../Bootloader/User/BSP/: internal_flash.c internal_flash_hw.c lsi_measure.c iwdg.c
    ../../Bootloader/User/Drivers/W25Q64/: w25q64_storage.c
    ../../Bootloader/User/IAP/: store.c image_store.c metadata.c product_boot.c upgrade_log.c
    ../User/IAP/: iap_fsm.c
    ../../Shared/: text_reply.c watchdog_contract.c
  group User/ProductClock
    ../User/BSP/: boot_clock.c boot_tick.c
software components: CMSIS:CORE 4.3.0
