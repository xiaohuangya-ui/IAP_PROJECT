LR_IROM1 0x08004000 0xC000 {
  ER_IROM1 0x08004000 0xC000 {
    *.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_IRAM1 0x20000000 0x5000 {
    .ANY (+RW +ZI)
  }
}
